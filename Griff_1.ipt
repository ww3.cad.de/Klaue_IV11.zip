# Autodesk Inventor part: Griff_1
## iProperties
Created: 2007-01
Part Number: Griff_1
Document SubType Name: Modeling
Designer: Jürgen
## Feature names
1. Extrusion1
