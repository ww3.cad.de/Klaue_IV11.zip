# Autodesk Inventor part: Klaue_rechts
## iProperties
Created: 2007-01
Part Number: Klaue_rechts
Document SubType Name: Modeling
Designer: Jürgen
## Feature names
1. Extrusion1
