# Autodesk Inventor assembly: Klaue
## iProperties
Created: 2007-01
Part Number: Klaue
Document SubType Name: Assembly
Designer: Besitzer
Author: Besitzer
