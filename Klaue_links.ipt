# Autodesk Inventor part: Klaue_links
## iProperties
Created: 2007-01
Part Number: Klaue_links
Document SubType Name: Modeling
Designer: Jürgen
## Feature names
1. Extrusion1
