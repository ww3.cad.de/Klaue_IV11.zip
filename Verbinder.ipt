# Autodesk Inventor part: Verbinder
## iProperties
Created: 2007-01
Part Number: Verbinder
Document SubType Name: Modeling
Designer: Jürgen
## Feature names
1. Extrusion1
